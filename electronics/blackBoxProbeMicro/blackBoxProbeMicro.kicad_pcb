# Repository Squantor/blackBoxProbe

File README.md:

# Black Box probes
This repository contains some hardware reimplementations of the [black magic probe](https://github.com/blacksphere/blackmagic/wiki).
## Structure
* Hardware contains schematics and PCB's
## Checking out
This project makes extensive use of submodules, use ```git clone --recurse-submodules https://github.com/Squantor/$(PROJECT).git``` to clone the repository and its submodules in one go.

## KiCad design electronics/blackBoxProbeMicro/blackBoxProbeMicro.kicad_pcb

File electronics/blackBoxProbeMicro/README.md:

# BlackBoxProbe Micro variant
A boxed clone of the 
[black magic probe](https://github.com/blacksphere/blackmagic/wiki). The 
black magic probe hardware is good but I would like something more then just a bare PCB and a more suitable connector for the serial connection. This project is here to solve that need. 
Do note, support the people at blacksphere technologies by buying their excellent probe. 
I have made this probe to have a nicer boxed version that I can use. This version has mostly 0402 components and is housed in a smaller box.
## TODO
* production of PCB at Oshpark
* Testing
* pictures
* writeup
## BOM
* [Hammond 1551M](http://www.hammondmfg.com/pdf/1551M.pdf)
* STM32F103
## Pictures
TODO

Parts:
C1: 1u; C_0603
C3, C11: 1uF; C_0402
C4: 10u; C_0603
C5, C6, C7, C8, C10: 1u; C_0402
C12, C13: 10p; C_0402
D1: yellow/green; LED_0603_hand
D2: amber; LED_0603_hand
D3: orange; LED_0603_hand
D4: blue; LED_0603_hand
D5: red; LED_0603_hand
F1: 0.5A; F_0603_hand
F2: 0.3A; F_0603_hand
FB1: 600; L_0603
FB2, FB3: 600; L_0402
H1, H2: Drill_Hole_no_metal; MountingHole_2.5mm_no_metal
J1: USB-C; USB-C-HRO-31-M-12
J2, J3: JTAG_2X05; Header-0127-2X05-H006
J4: DevBoardUartOutput; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
N1: OHWLOGO; OSHW-Symbol_6.7x6mm_SilkScreen
N2: V:20240218; Label_Generic
N3: JLCJLCJLC; Label_Generic
Q1: BSD840N; SOT363-ONsemi
Q2: NTJD4152P; SOT363-ONsemi
R1: 330; R_0402_hand
R2, R3, R4, R5: 1K; R_0402_hand
R6, R11, R12, R20, R28: 10K; R_0402_hand
R7, R10: 4.7K; R_0402_hand
R8, R9, R13, R14, R15, R17: 100; R_0402_hand
R16: 1.5K; R_0402_hand
R18, R22, R23, R24, R25: 47K; R_0402_hand
R19, R21: 5.1K; R_0402_hand
R27, R34: 22R; R_0402_hand
S1: DFU; TD-85XU
TP1: tmsdir; TestPoint_hole_H03R07
U1: MCP1702-MB; SOT89-NXP
U2: DT1446-04S; SOT363-DiodesInc
U3: STM32F103CBT; LQFP48-STM
Y1: 8MHz; Crystal_3225_4

Connections:
/BUTTON: R6.2, S1.1, U3.25 (PB12/SPI2_NSS/I2C2_SMBAl/USART3_CK/TIM1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)
/CC1: J1.A5 (CC1), R19.2
/CC2: J1.B5 (CC2), R21.2
/LED0: R2.1, U3.20 (PB2/BOOT1)
/LED1: R3.1, U3.21 (PB10/I2C2_SCL/USART3_TX/TIM2_CH3)
/LED2: R4.1, U3.22 (PB11/I2C2_SDA/USART3_RX/TIM2_CH4)
/MCU_RST: C10.2, J2.10 (nRESET), R18.2, U3.7 (NRST)
/MCU_TCK: J2.4 (SWDCLK/TCK), R23.1, U3.37 (PA14/JTCK/SWCLK)
/MCU_TDI: J2.8 (TDI), R25.1, U3.38 (PA15/JTDI/TIM2_CH1_ETR/_PA15/SPI1_NSS)
/MCU_TDO: J2.6 (SWO/TDO), R24.1, U3.39 (PB3/JTDO/TIM2_CH2/TRACESWO/SPI1_SCK)
/MCU_TMS: J2.2 (SWDIO/TMS), R22.1, U3.34 (PA13/_JTMS/SWDIO)
/PROBE_E_RST: J3.10 (nRESET), Q1.5 (G2), Q1.6 (D1), R20.2
/PROBE_E_RX: J4.3 (RX), R15.1
/PROBE_E_TCK: J3.4 (SWDCLK/TCK), R14.1
/PROBE_E_TDI: J3.8 (TDI), R9.1
/PROBE_E_TDO: J3.6 (SWO/TDO), R17.1
/PROBE_E_TMS: J3.2 (SWDIO/TMS), R13.1
/PROBE_E_TX: J4.4 (TX), R8.1
/PROBE_I_RST: Q1.2 (G1), U3.12 (PA2/USART2_TX/ADC12_IN2/TIM2_CH3)
/PROBE_I_RST_SEN: Q1.3 (D2), U3.17 (PA7/SPI1_MOSI/ADC12_IN7/TIM3_CH2/TIM1_C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)
/PROBE_I_RX: R15.2, U3.31 (PA10/USART1_RX/_TIM1_CH3)
/PROBE_I_TCK: R14.2, U3.15 (PA5/SPI1_SCK/ADC12_IN5)
/PROBE_I_TDI: R9.2, U3.13 (PA3/USART2_RX/ADC12_IN3/TIM2_CH4)
/PROBE_I_TDO: R17.2, U3.16 (PA6/SPI1_MISO/ADC12_IN6/TIM3_CH1/TIM1_B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)
/PROBE_I_TMS: R13.2, U3.14 (PA4/SPI1_NSS/USART2_CK/ADC12_IN4)
/PROBE_I_TX: R8.2, U3.30 (PA9/USART1_TX/_TIM1_CH2)
/PROBE_TMS_DIR: TP1.1, U3.11 (PA1/USART2_RTS/ADC12_IN1/TIM2_CH2)
/PROBE_VDD: F2.1, J3.1 (VCC), J4.2 (VBUS), R5.1, R10.1, R20.1
/TARGET_PWR_EN: Q2.2 (G1), Q2.5 (G2), R28.2, U3.19 (PB1/ADC12_IN9/TIM3_CH4/TIM1_CH3N)
/TARGET_PWR_SENSE: C11.2, R10.2, R11.1, U3.18 (PB0/ADC12_IN8/TIM3_CH3/TIM1_CH2N)
/USB_D+: R34.1, U3.33 (PA12/USART1_RTS/_CANTX/USBDP/TIM1_ETR)
/USB_D-: R27.1, U3.32 (PA11/USART1_CTS/_CANRX/_USBDM/TIM1_CH4)
/USB_D_C+: J1.A6 (DP1), J1.B6 (DP2), R16.2, R34.2, U2.1 (IO_1)
/USB_D_C-: J1.A7 (DN1), J1.B7 (DN2), R27.2, U2.6 (IO_4)
/USB_PU: R16.1, U3.29 (PA8/USART1_CK/TIM1_CH1/MCO)
/USB_V: R7.2, R12.1, U3.26 (PB13/SPI2_SCK/USART3_CTS/TIM1_CH1N_)
/VBUS: FB1.2, J1.A4B9 (VBUS), J1.B4A9 (VBUS)
/VDD: C4.1, C5.1, C6.1, C7.1, FB3.2, J2.1 (VCC), Q2.6 (D1), R1.1, R6.1, R18.1, R22.2, R24.2, R25.2, U1.3 (Vout), U3.1 (VBAT), U3.24 (VDD_1), U3.36 (VDD_2), U3.40 (PB4/JNTRST/TIM3_CH1/SPI1_MISO), U3.41 (PB5/I2C1_SMBAl/TIM3_CH2/SPI1_MOSI), U3.42 (PB6/I2C1_SCL/TIM4_CH1/USART1_TX), U3.48 (VDD_3)
/VDDA: C8.1, FB3.1, U3.9 (VDDA)
/VSS: C1.2, C3.1, C4.2, C5.2, C6.2, C7.2, C10.1, C11.1, C12.2, C13.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), FB2.2, J1.A1B12 (GND), J1.B1A12 (GND), J1.S (Shield), J2.3 (GND), J2.5 (GND), J2.9 (GNDDET), J3.3 (GND), J3.5 (GND), J3.9 (GNDDET), J4.1 (GND), Q1.1 (S1), Q1.4 (S2), R11.2, R12.2, R19.1, R21.1, R23.2, S1.2, U1.1 (GND), U2.2 (VSS), U3.23 (VSS_1), U3.35 (VSS_2), U3.44 (BOOT0), U3.47 (VSS_3), Y1.2, Y1.4
/VSSA: C8.2, FB2.1, U3.8 (VSSA)
/VUSB: C1.1, C3.2, F1.1, R7.1, U1.2 (Vin), U2.5 (VDD)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: F1.2, FB1.1
unnamed: F2.2, Q2.3 (D2)
unnamed: Q2.1 (S1), Q2.4 (S2), R28.1
unnamed: C12.1, U3.5 (OSC_IN/PD0), Y1.1
unnamed: C13.1, U3.6 (OSC_OUT/PD1), Y1.3

Notes on the sheet:
Regulator
USB connection
Labels and mechanical
TPWR sensing & sensing
output connections
Series matching
Microcontroller
TODOs
User interface
MCU_JTAG

Board: 4 copper layers, 29.0 x 29.0 mm, 66 parts (3 on the bottom side), 52 nets.

## KiCad design hardware/blackBoxProbeSmall/blackBoxProbeSmall.kicad_pcb

File hardware/blackBoxProbeSmall/README.md:

# blackBoxProbe Small variant
A boxed clone of the 
[black magic probe](https://github.com/blacksphere/blackmagic/wiki). The 
black magic probe hardware is good but I would like something more then just a bare PCB. This project is here to solve that need. 
Do note, support the people at blacksphere technologies by buying their excellent probe. 
I have made this probe to have a nicer boxed version that I can use. This version has mostly 0402 components and is housed in a smaller box.
## DONE
* Schematic entry, copied from [black magic probe V2.1](https://github.com/blacksphere/blackmagic/wiki/files/bmpm_v2_1c_schematic.pdf).
## In progress
* Layout, board outline matches a [Hammond 1551G](http://www.hammondmfg.com/pdf/1551G.pdf)
## TODO
* production of PCB+stencils
* Testing
* pictures
* writeup
## BOM
TODO
## Pictures
TODO

Board: 4 copper layers, 44.0 x 29.0 mm, 63 parts (2 on the bottom side), 62 nets.

Parts:
C1: 1u; C_0603
C2: 100N; C_0603
C4, C9, C14: 10u; C_0603
C5, C6, C7, C8, C10, C15, C16, C17, C18, C19, C20, C21, C22: 1u; C_0402
C11: 1uF; C_0402
C12, C13: 10p; C_0402
DA1: mentor_1296.4124
F1: 0.5A; F_0603_hand
F2: 0.3A; F_0603_hand
FB1: Ferrite_Bead; L_0603
FB2, FB3: Ferrite_Bead; L_0402
H1, H2: Drill_Hole_no_metal; MountingHole_2.5mm_no_metal
J1: USB-ID; USB-muB-SMD_TH
J2, J3: JTAG_2X05; Header-0127-2X05-H006
J4: DevBoardUartOutput; JST_PH_S4B-PH-K_04x2.00mm_Angled
N1: OHWLOGO; OSHW-Symbol_6.7x6mm_SilkScreen
N2: V20200422; Label_Generic
Q1: Q_NMOS_DUAL; SOT363-hand
Q2: Q_PMOS_DUAL; SOT363-hand
R5, R33: 33; R_0402_hand
R6, R11, R12, R20, R28: 10K; R_0402_hand
R7, R10: 4.7K; R_0402_hand
R16: 1.5K; R_0402_hand
R18: 47K; R_0402_hand
R27, R34: 22; R_0402_hand
RN1: 470; R_Array_Convex_4x0402
RN2: 47K; R_Array_Convex_4x0402
RN3, RN4: 33; R_Array_Convex_4x0402
S1: 2pin_tact_switch; DTSM3
U1: MCP1702-MB; SOT89-NXP-Viatab
U2: USBLC6-2; SOT23-6-HAND
U3: STM32F103CBT; SOT313-2
U4, U5, U6, U7: 74X2T45; SOT765-1-NXP
Y1: 8MHz; Crystal_3225_4

Connections:
/BUTTON: R6.2, S1.2, U3.25
/LED0: RN1.7, U3.20
/LED1: RN1.6, U3.21
/LED2: RN1.5, U3.22
/MCU_RST: C10.2, J2.10, R18.2, U3.7
/MCU_TCK: RN2.6, RN3.3, U3.37
/MCU_TDI: RN2.8, RN3.1, U3.38
/MCU_TDO: RN2.7, RN3.2, U3.39
/MCU_TMS: RN2.5, RN3.4, U3.34
/PROBE_E_RST: J3.10, Q1.5, Q1.6, R20.2
/PROBE_E_RX: R33.2, U6.6
/PROBE_E_TCK: RN4.3, U5.6
/PROBE_E_TDI: RN4.1, U5.7
/PROBE_E_TDO: RN4.2, U6.7
/PROBE_E_TMS: RN4.4, U7.6
/PROBE_E_TX: R5.2, U4.6
/PROBE_I_RST: Q1.2, U3.12
/PROBE_I_RST_SEN: Q1.3, U3.17
/PROBE_I_RX: U3.31, U6.3
/PROBE_I_TCK: U3.15, U5.3
/PROBE_I_TDI: U3.13, U5.2
/PROBE_I_TDO: U3.16, U6.2
/PROBE_I_TMS: U3.14, U7.3
/PROBE_I_TX: U3.30, U4.3
/PROBE_TMS_DIR: U3.11, U7.5
/PROBE_VDD: C16.1, C18.1, C20.1, C22.1, F2.1, J3.1, J4.2, R10.1, R20.1, U4.8, U5.8, U6.8, U7.8
/TARGET_PWR_EN: Q2.2, Q2.5, R28.2, U3.19
/TARGET_PWR_SENSE: C11.2, R10.2, R11.1, U3.18
/USB_D+: R34.1, U3.33
/USB_D-: R27.1, U3.32
/USB_D_C+: J1.3, U2.3
/USB_D_C-: J1.2, U2.1
/USB_PU: R16.1, U3.29
/USB_V: R7.2, R12.1, U3.26
/VDD: C4.1, C5.1, C6.1, C7.1, C14.1, C15.1, C17.1, C19.1, C21.1, FB3.2, J2.1, Q2.6, R6.1, R18.1, RN1.8, RN2.1, RN2.2, RN2.4, U1.3, U3.1, U3.24, U3.36, U3.40, U3.41, U3.42, U3.48, U4.1, U4.5, U5.1, U5.5, U6.1, U7.1
/VDDA: C8.1, C9.1, FB3.1, U3.9
/VSS: C1.2, C2.1, C4.2, C5.2, C6.2, C7.2, C10.1, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, DA1.5, DA1.6, DA1.7, DA1.8, FB2.2, J1.4, J1.5, J2.3, J2.5, J2.9, J3.3, J3.5, J3.9, J4.1, Q1.1, Q1.4, R11.2, R12.2, RN2.3, S1.1, U1.1, U2.2, U3.23, U3.35, U3.44, U3.47, U4.2, U4.4, U4.7, U5.4, U6.4, U6.5, U7.2, U7.4, U7.7, Y1.2, Y1.4
/VSSA: C8.2, C9.2, FB2.1, U3.8
/VUSB: C1.1, F1.1, R7.1, U1.2, U2.5
unnamed: C2.2, J1.S
unnamed: C12.1, U3.5, Y1.1
unnamed: C13.1, U3.6, Y1.3
unnamed: DA1.1, RN1.1
unnamed: DA1.2, RN1.2
unnamed: DA1.3, RN1.3
unnamed: DA1.4, RN1.4
unnamed: F1.2, FB1.1
unnamed: F2.2, Q2.3
unnamed: FB1.2, J1.1
unnamed: J2.2, RN3.5
unnamed: J2.4, RN3.6
unnamed: J2.6, RN3.7
unnamed: J2.8, RN3.8
unnamed: J3.2, RN4.5
unnamed: J3.4, RN4.6
unnamed: J3.6, RN4.7
unnamed: J3.8, RN4.8
unnamed: J4.3, R33.1
unnamed: J4.4, R5.1
unnamed: Q2.1, Q2.4, R28.1
unnamed: R16.2, R34.2, U2.4
unnamed: R27.2, U2.6

## KiCad design blackBoxProbeSmall/blackBoxProbeSmall.kicad_pcb

Parts:
C1: 1u; C_0603
C2: 100N; C_0805
C4, C9, C14: 10u; C_0805
C5, C6, C7, C8, C10, C11, C15, C16, C17, C18, C19, C20, C21, C22: 100n; C_0402
C12, C13: 10p; C_0402
DA1: mentor_1296.4124
H1, H2: Drill_Hole_no_metal; MountingHole_2.5mm_no_metal
J1: USB-ID; SquantorUsb-USB-UB-SMD4H
J2, J3: JTAG_2X05; Header-0127-2X05-H006
J4: Conn_01x04; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
N1: OHWLOGO; OSHW-Symbol_6.7x6mm_SilkScreen
N2: V20181130; Label_version
Q1: Q_NMOS_DUAL; SOT363-hand
Q2: Q_PMOS_DUAL; SOT363-hand
R1: FB; R_0402_hand
R4, R5: R; R_0402_hand
R6, R11, R12, R20, R28, R37, R38: 10K; R_0402_hand
R7, R10: 4.7K; R_0402_hand
R8, R9, R13, R14, R15, R21, R22, R24, R25, R26, R33, R35: 100; R_0402_hand
R16: 1.5K; R_0402_hand
R18: 47K; R_0402_hand
R27, R34, R36: 22; R_0402_hand
R29, R30, R31, R32: 330; R_0402_hand
S1: 2pin_tact_switch; DTSM3
U1: MCP1702-MB; SOT89-ViaTab-Microchip-MB
U2: USBLC6-2; SOT23-6-HAND
U3: STM32F103CBT; SOT313-2
U4, U5, U6, U7: 74X2T45; SOT765-1-NXP
Y1: 8.000MHz; X_5.0_3.2

Connections:
+3V3: C4.1, C5.1, C6.1, C7.1, C14.1, C15.1, C17.1, C19.1, C21.1, J2.1 (VCC), Q2.6 (D1), R4.2, R6.1, R18.1, R29.2, R37.1, U1.3 (Vout), U3.1 (VBAT), U3.24 (VDD_1), U3.36 (VDD_2), U3.40 (PB4/JNTRST/TIM3_CH1/SPI1_MISO), U3.41 (PB5/I2C1_SMBAl/TIM3_CH2/SPI1_MOSI), U3.42 (PB6/I2C1_SCL/TIM4_CH1/USART1_TX), U3.48 (VDD_3), U4.1 (VCCA), U4.5 (DIR), U5.1 (VCCA), U5.5 (DIR), U6.1 (VCCA), U7.1 (VCCA)
+5V: C1.1, R1.2, R7.1, U1.2 (Vin), U1.TAB (Vin), U2.5 (VCC)
/BUTTON: R6.2, S1.2, U3.25 (PB12/SPI2_NSS/I2C2_SMBAl/USART3_CK/TIM1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)
/LED0: R30.2, U3.20 (PB2/BOOT1)
/LED1: R31.2, U3.21 (PB10/I2C2_SCL/USART3_TX/TIM2_CH3)
/LED2: R32.2, U3.22 (PB11/I2C2_SDA/USART3_RX/TIM2_CH4)
/MCU_RST: C10.2, R15.2, R18.2, U3.7 (NRST)
/MCU_TCK: R8.2, R38.2, U3.37 (PA14/JTCK/SWCLK)
/MCU_TDI: R9.2, U3.38 (PA15/JTDI/TIM2_CH1_ETR/_PA15/SPI1_NSS)
/MCU_TDO: R14.2, U3.39 (PB3/JTDO/TIM2_CH2/TRACESWO/SPI1_SCK)
/MCU_TMS: R13.2, R37.2, U3.34 (PA13/_JTMS/SWDIO)
/PROBE_E_RST: Q1.5 (G2), Q1.6 (D1), R20.2, R26.2
/PROBE_E_RX: R35.2, U6.6 (2B)
/PROBE_E_TCK: R21.2, U5.7 (1B)
/PROBE_E_TDI: R22.2, U5.6 (2B)
/PROBE_E_TDO: R25.2, U6.7 (1B)
/PROBE_E_TMS: R24.2, U7.6 (2B)
/PROBE_E_TX: R33.2, U4.6 (2B)
/PROBE_E_VDD: C16.1, C18.1, C20.1, C22.1, R20.1, R36.2, U4.8 (VCCB), U5.8 (VCCB), U6.8 (VCCB), U7.8 (VCCB)
/PROBE_I_RST: Q1.2 (G1), U3.12 (PA2/USART2_TX/ADC12_IN2/TIM2_CH3)
/PROBE_I_RST_SEN: Q1.3 (D2), U3.17 (PA7/SPI1_MOSI/ADC12_IN7/TIM3_CH2/TIM1_C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)
/PROBE_I_RX: U3.31 (PA10/USART1_RX/_TIM1_CH3), U6.3 (2A)
/PROBE_I_TCK: U3.15 (PA5/SPI1_SCK/ADC12_IN5), U5.2 (1A)
/PROBE_I_TDI: U3.13 (PA3/USART2_RX/ADC12_IN3/TIM2_CH4), U5.3 (2A)
/PROBE_I_TDO: U3.16 (PA6/SPI1_MISO/ADC12_IN6/TIM3_CH1/TIM1_B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), U6.2 (1A)
/PROBE_I_TMS: U3.14 (PA4/SPI1_NSS/USART2_CK/ADC12_IN4), U7.3 (2A)
/PROBE_I_TX: U3.30 (PA9/USART1_TX/_TIM1_CH2), U4.3 (2A)
/PROBE_TMS_DIR: U3.11 (PA1/USART2_RTS/ADC12_IN1/TIM2_CH2), U7.5 (DIR)
/PROBE_VDD: J3.1 (VCC), J4.1, Q2.3 (D2), R10.1, R36.1
/TARGET_PWR_EN: Q2.2 (G1), Q2.5 (G2), R28.2, U3.19 (PB1/ADC12_IN9/TIM3_CH4/TIM1_CH3N)
/TARGET_PWR_SENSE: C11.2, R10.2, R11.1, U3.18 (PB0/ADC12_IN8/TIM3_CH3/TIM1_CH2N)
/USB_D+: R34.1, U3.33 (PA12/USART1_RTS/_CANTX/USBDP/TIM1_ETR)
/USB_D-: R27.1, U3.32 (PA11/USART1_CTS/_CANRX/_USBDM/TIM1_CH4)
/USB_D_C+: J1.3 (D+), U2.3 (I/O2)
/USB_D_C-: J1.2 (D-), U2.1 (I/O1)
/USB_PU: R16.1, U3.29 (PA8/USART1_CK/TIM1_CH1/MCO)
/USB_V: R7.2, R12.1, U3.26 (PB13/SPI2_SCK/USART3_CTS/TIM1_CH1N_)
GND: C1.2, C2.1, C4.2, C5.2, C6.2, C7.2, C10.1, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, DA1.5, DA1.6, DA1.7, DA1.8, J1.4 (ID), J1.5 (GND), J2.3 (GND), J2.5 (GND), J2.9 (GNDDET), J3.3 (GND), J3.5 (GND), J3.9 (GNDDET), J4.4, Q1.1 (S1), Q1.4 (S2), R5.2, R11.2, R12.2, R38.1, S1.1, U1.1 (GND), U2.2 (GND), U3.23 (VSS_1), U3.35 (VSS_2), U3.44 (BOOT0), U3.47 (VSS_3), U4.2 (1A), U4.4 (GND), U4.7 (1B), U5.4 (GND), U6.4 (GND), U6.5 (DIR), U7.2 (1A), U7.4 (GND), U7.7 (1B)
GNDA: C8.2, C9.2, R5.1, U3.8 (VSSA)
unnamed: C2.2, J1.S (Shield)
unnamed: C12.1, U3.5 (OSC_IN/PD0), Y1.1
unnamed: C13.1, U3.6 (OSC_OUT/PD1), Y1.2
unnamed: DA1.1, R32.1
unnamed: DA1.2, R31.1
unnamed: DA1.3, R30.1
unnamed: DA1.4, R29.1
unnamed: J1.1 (VBUS), R1.1
unnamed: J2.2 (SWDIO/TMS), R13.1
unnamed: J2.4 (SWDCLK/TCK), R8.1
unnamed: J2.6 (SWO/TDO), R14.1
unnamed: J2.8 (TDI), R9.1
unnamed: J2.10 (nRESET), R15.1
unnamed: J3.2 (SWDIO/TMS), R24.1
unnamed: J3.4 (SWDCLK/TCK), R21.1
unnamed: J3.6 (SWO/TDO), R25.1
unnamed: J3.8 (TDI), R22.1
unnamed: J3.10 (nRESET), R26.1
unnamed: J4.2, R33.1
unnamed: J4.3, R35.1
unnamed: Q2.1 (S1), Q2.4 (S2), R28.1
unnamed: R16.2, R34.2, U2.4 (I/O2)
unnamed: R27.2, U2.6 (I/O1)
VDDA: C8.1, C9.1, R4.1, U3.9 (VDDA)

Board: 4 copper layers, 74 parts (0 on the bottom side), 63 nets, no tracks yet.

## Commit log

2018-03-30 * updated readme
2018-03-30 * added blackboxprobe project based on PP40 bottom PCB 4 layer
2018-03-30 * schematic layout of usb input and powersupply * PCB placing of usb input and powersupply
2018-04-03 * added usb protection diode
2018-04-04 * updated path references to the schematic libraries
2018-04-09 * updated paths to libraries
2018-04-16 * placed controller and schematic entry of microcontroller power
2018-06-13 DONE: switched over case to hammond 1551G
2018-06-13 WIP: further copying of the black box probe schematic
2018-06-14 WIP: added JTAG/SWD interface bits, still reset sensing needs to be done
2018-06-14 DONE: Finished schematic WIP: review WIP: Assign components
2018-06-21 FIX: fixed wrong schematic symbol for the switch, needs to be dual PMOS DONE: assigned all components a footprint
2018-06-21 DONE: imported netlist to PCB WIP: initial placing, thinking about replacing all R and C by 0402
2018-06-22 WIP: Switching to bigger case
2018-06-22 DONE: switched to new PCB layout WIP: rough component placement
2018-06-22 WIP: initial placement of all the components, start the tetris music!
2018-06-22 DONE: netlist updates
2018-06-23 FIX: fixed boot0 pulldown to something stronger WIP: further component placement WIP: need to replace JTAG headers to TH headers
2018-06-23 DONE: tuned USB differential pair length WIP: inital layouting WIP: further optimal placing
2018-06-24 WIP: More routing DONE: optimization of components, removing redudant/superflous components WIP: more optimal placement, maybe I can fit this in a 44 by 30mm box?
2018-06-24 WIP: Futher layout, done power switch, reset circuit
2018-06-24 WIP: additional routing WIP: placed the level shifting network WIP: Further component optimization and removal
2018-06-24 DONE: routing of all nets, visual check still needed
2018-06-24 FIX: incorrect pin mapping of STM32 DONE: changed to 3mm leds, plenty of space DONE: routing WIP: Silk/value placing
2018-06-24 DONE: placed all the silkscreen designations
2018-06-24 FIX: forgotten one disconnected net
2018-06-24 DONE: fixed crystal layout DONE: added a guard trace to isolate crystal from VSSA
2018-06-25 FIX: incorrect naming of 74X2T45 gate FIX: missing USB series resistors FIX: added another label for the project name
2018-06-25 DONE: rerouted everything after fixing the pinout of the header
2018-06-26 WIP: final placement of silk, need some checks
2018-06-26 DONE: Silk placement ready for production, let it sit for one day
2018-06-27 DONE: last silk screen modifications
2018-06-27 DONE: more silkscreen position changes
2018-06-27 DONE: actualised plotting settings
2018-06-27 DONE: updated version number
2018-06-27 DONE: add gerbers sent to the fab
2018-06-29 Updated readme and added schematic pdf
2018-07-15 updated README.md with current project status
2018-07-15 fixed errors and some minor modifications
2018-07-15 some small modifications
2018-07-15 minor pcb updates
2018-07-15 fixed decoupling of the level shifters on the probe side
2018-07-15 placed and routed all components/airwires
2018-07-15 placed silkscreen labels
2018-07-15 more silkscreen moves
2018-07-15 more silkscreen placings
2018-07-15 additional changes to layout and some traces
2018-07-16 minor silkscreen updates
2018-07-16 updated gerbers to V20180716
2018-07-28 converted to kicad 5 and some modifications
2018-07-28 silkscreen updates
2018-07-28 moved project to blackBoxProbeBig
2018-07-28 renaming blackBoxProbe to the big variant with hammond 1551R
2018-07-28 updated plots and some minor via updates
2018-07-28 copied blackBoxProbeBig and copied over to Small
2018-07-28 added gerber plots
2018-07-28 replaced all R's C's and inserted new box outline
2018-07-28 small updates
2018-09-03 footprint updates
2018-09-03 updates to silk after footprint updates
2018-11-30 added zip files to gitignore
2018-11-30 simplified schematic to be more in line with black magic probe v2.1
2018-11-30 updated versionnumber
2018-11-30 removed old plot location
2018-11-30 added pcblibrary submodule
2018-11-30 updated plot
2018-11-30 updated project references
2018-11-30 updated regulator with via variant
2018-11-30 schematic simplifications, regulator rework, silk movements
2018-11-30 redoing the small blackboxprobe
2018-11-30 added black box probe small
2018-11-30 schematic conversion done, started placement of components
2018-12-08 newer library version
2018-12-08 updated component footprints
2018-12-08 added all the private libraries
2018-12-08 small updates in placement
2018-12-08 further placement of components, everything fits on pcb, now compacting due to smaller footprints
2019-07-05 added proper landing page
2019-07-05 moving around project files
2019-07-05 updating project
2019-07-26 updated component library
2019-07-26 removed defunct library
2019-07-26 few Rs and C's have 3d models now
2019-07-26 added 0402's with 3d models
2019-08-04 updated pcb component library
2019-08-04 updated pcb library
2019-08-04 added fuse and updated 3d components
2019-08-04 updated to ignore caches
2019-08-04 reduced crystal size, replaced 0805 with 0603
2019-08-15 added schematic backups to gitignore
2019-08-15 added named connectors
2019-08-15 WIP: component changes, footprint updates
2019-08-15 updated subrepo
2019-08-15 updated few ferrite beads
2019-08-15 switching from global nets to sheet wide nets
2019-08-15 more library updates
2019-08-15 imported changes into PCB to check 3d models
2019-08-15 updated nets to non global ones
2019-08-16 changed label font sizes
2019-08-16 adding series resistor to output drivers
2019-08-16 added series drive resistors
2019-08-16 component assignment, updated 3d models
2019-08-16 updated library
2019-08-16 updated 3d models of footprints
2019-08-16 updated 3d models
2019-08-16 initial component placement completed
2019-08-16 more layout
2019-08-19 minor layout changes
2019-08-19 more layout and some silk placement, need to move the microcontroller closer to the programming header to create more space
2019-08-19 compacted microcontroller area more
2019-08-19 removed last references of PROBE_E_VDD
2019-08-19 further layout
2020-01-27 merging some things into resistor networks
2020-01-31 updated PCB library and defunct library
2020-01-31 updated schematic of small blackbox probe
2020-01-31 updated few schematic flaws
2020-01-31 small changes to make routing easier
2020-01-31 WIP routing/placement
2020-01-31 change pinning to ease routing
2020-01-31 WIP place/route, starting with level shifters
2020-01-31 done place and route, silk placement starting
2020-01-31 silk placement done, wait/review stage
2020-01-31 some placement fixes, silk fixes and changed paste aperatures
2020-02-02 silk placement mistakes fixed, removed groundplane under crystal
2020-02-02 further beautification and some trace reroutings
2020-02-05 updated versionnumber and some minor silk changes
2020-03-22 visibility changes to help assembly
2020-03-27 changed position of component values to ease assembly
2020-03-27 added black box probe mini box cover
2020-03-27 minor additions
2020-03-28 updated cover
2020-03-28 added body for the black box probe
2020-03-28 renamed blackbox cover
2020-04-10 moved some components away from screw hole, updated versionnumber
2020-04-22 small improvements, moved components near drill holes
2021-06-15 renamed to be consistent with general project structure
2021-06-15 updated to newer PCB library
2021-06-15 started with BlackBoxProbeMicro
2021-06-15 reworking schematic
2021-06-15 updated STM32 symbol
2021-06-15 further stripping and changing of circuit
2021-06-15 initial placement, schematic changes, change to 4 layer board
2021-06-16 starting to optimize most component sizes
2021-06-16 additional changes
2021-06-17 completed and partitioned schematic
2021-06-19 sectioned off more schematic components
2021-06-19 added STM32 LQFP48
2021-06-19 updated to LQFP footprint
2021-06-19 further placement, routing local component clusters
2021-06-19 changed label footprint, further routing and minor placement improvements
2021-06-19 further routing
2021-06-20 routed everything, time for silk placement
2021-06-20 updated pinheader 2X5 1.27mm
2021-06-20 silk optimizations
2021-06-20 updated versionnumber, changed/updated SWD/JTAG header footprints
2021-06-20 some minor trace optimizations
2021-06-20 changed design rules to match 4 layer specs, passing DRC, silk placement
2021-06-20 further silk and routing optimizations
2021-06-21 minor optimizations
2021-06-22 added capacitor to USB protection diodes
2021-06-22 updated SOT-363 footprints
2021-06-22 updated dual transistor footprints
2021-06-23 small routing updates
2021-06-23 updated versionnumber, ready for production
2021-06-23 updated readme and progress
2021-06-30 replaced all resistor networks with 0402 resistors, removed SWD series resistors for programming the main MCU, changed series resistors for the programming interface, updated versionnumber
2021-06-30 WIP placing and routing new resistors
2021-06-30 placed and routed new resistors
2021-06-30 some silk placement, and component replacement to accomodate silk
2021-07-01 silk placement done
2021-07-04 minor silk improvements, component placement
2021-07-06 added plot options, updated plot output
2021-07-06 added JLC label, updated versionnumber
2021-08-18 moved usb-c connector more to the edge
2021-08-18 updated git url to use ssh, https is depricated
2021-08-18 fixed incorrect path to footprint library
2021-08-18 changed ESD diode to something smaller and cheaper
2021-08-24 small trace movement
2021-08-26 removed ground plane underneath crystal oscillator section
2021-08-26 added casing for black box probe micro
2021-08-26 moved JTAG out connector a bit from the edge
2021-08-26 placement, routing, and silk optimizations
2023-02-24 removed rescue library
2023-02-24 updated library references
2023-02-24 fixing ERC/DRC errors after component updates
2023-09-29 updated gitignore
2023-09-29 small uppdates
2023-09-29 added additional ground planes top and bottom
2023-12-14 WIP adapting to aisler DRC
2023-12-14 more selective git ignores
2023-12-14 enabled visibility of lid of the blackbox micro box
2023-12-17 some trace optimizations
2024-01-17 updated gitignore for kicad 7
2024-01-17 updated url
2024-01-17 WIP updating parts and PCB, replacing silk parts
2024-01-18 WIP relayout on new DRC rules
2024-01-21 adjustments of silk, fixing ERC errors
2024-02-02 all planes are now VSS planes, some routing improvements
2024-02-16 reviewed and ready for production
2024-02-18 prepared for production
